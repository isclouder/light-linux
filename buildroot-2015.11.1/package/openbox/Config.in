## buildroot-2015.11.1/package/openbox/Config.in
```kconfig
config BR2_PACKAGE_OPENBOX
	bool "openbox"
	help
	  This package implements the openbox.
```
